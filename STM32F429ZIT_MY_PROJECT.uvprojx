# Keil uVision project STM32F429ZIT_MY_PROJECT.uvprojx, settings and files
target STM32F429ZIT_MY_PROJECT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429ZIT_MY_PROJECT
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx,STM32F429X
  c include: .\INC\CMSIS;.\INC\STARTUP;.\INC\MAIN;.\INC\GPIO;.\INC\RCC;.\INC\FREERTOS;.\INC\SPI;.\INC\LCD;.\INC\SDRAM;.\INC\FONTS;.\INC\I2C;.\INC\TOUCHSCREEN
  asm include: .\SRC\STARTUP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MAIN
    ./SRC/MAIN/: main.c stm32f4xx_it.c
  group RCC
    ./SRC/RCC/: rcc.c
  group GPIO
    ./SRC/GPIO/: gpio.c
  group STARTUP
    ./SRC/STARTUP/: startup_stm32f429xx.s system_stm32f4xx.c
  group FREERTOS
    ./SRC/FREERTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c port.c heap_4.c
    ./SRC/CMSIS/: cmsis_os.c
  group LCD
    ./SRC/LCD/: lcd.c text_draw_driver.c
  group SPI
    ./SRC/SPI/: spi.c
  group SDRAM
    ./SRC/SDRAM/: sdram.c
  group FONTS
    ./SRC/FONTS/: font8.c font12.c font16.c font20.c font24.c
  group I2C
    ./SRC/I2C/: i2c.c
  group TOUCHSCREEN
    ./SRC/TOUCHSCREEN/: touchscreen.c
